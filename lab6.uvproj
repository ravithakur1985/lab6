# Keil uVision project lab6.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: lab6
  c flags: Optim=1 wLevel=2
  c include: ..\Lab6;..\STM32F\includes
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f30x.s main.c cli.c stm32f3_Button.c stm32f3_Exec.c stm32f3_GeneralTimer2.c stm32f3_LEDS.c stm32f3_Tools.c stm32f3_UART.c stm32f3_Flash.c
    ../STM32F/src/: system_stm32f30x.c
